LINUX-YOCTO_INC_XILINX-ZYNQMP = ""
LINUX-YOCTO_INC_XILINX-ZYNQMP:xilinx-zynqmp = "linux-yocto-xilinx-zynqmp.inc"
require ${LINUX-YOCTO_INC_XILINX-ZYNQMP}

KBRANCH:xilinx-zynqmp = "v6.1/standard/sdkv6.1/xlnx-soc"
