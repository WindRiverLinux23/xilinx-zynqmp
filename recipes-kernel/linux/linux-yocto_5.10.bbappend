require linux-yocto-xilinx-zynqmp.inc

KBRANCH:xilinx-zynqmp  = "v5.10/standard/sdkv5.10/xlnx-soc"

LINUX_VERSION:xilinx-zynqmp ?= "5.10.x"
