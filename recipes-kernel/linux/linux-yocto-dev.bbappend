require linux-yocto-xilinx-zynqmp.inc 

KBRANCH:xilinx-zynqmp  = "standard/xlnx-soc"

LINUX_VERSION:xilinx-zynqmp ?= "5.13.x"
